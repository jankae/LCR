<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lcr-ad5941.ewp</path>
    </project>
    <batchBuild />
</workspace>
