# IAR project lcr-ad5941.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VE ST STM32F303VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303xE; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\LCRMeter\Application\; ..\LCRMeter\Application\GUI\; ..\LCRMeter\Application\GUI\Dialog\; ..\LCRMeter\Drivers\Board\; ..\LCRMeter\Drivers\Board\AD5940\; ..\LCRMeter\Drivers\Board\Display\; ..\LCRMeter\Drivers\CMSIS\Include\; ..\LCRMeter\Drivers\CMSIS\Device\ST\STM32F3xx\Include\; ..\LCRMeter\Drivers\STM32F3xx_HAL_Driver\Inc\; ..\LCRMeter\Inc\; ..\LCRMeter\Middlewares\Third_Party\FatFs\src\; ..\LCRMeter\Middlewares\Third_Party\FreeRTOS\Source\include\; ..\LCRMeter\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; src\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\; ..\LCRMeter\Middlewares\ST\STM32_USB_Device_Library\Core\Inc\; ..\LCRMeter\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\LCRMeter\Inc\
  ILINK.IlinkOutputFile: lcr-ad5941.out
  ILINK.IlinkIcfFile: stm32f303xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Project/Application
    ../LCRMeter/Application/: Config.cpp file.cpp Frontend.cpp input.cpp LCR.cpp Persistence.cpp Sound.cpp Start.cpp Sweep.cpp touch.cpp
  group Project/Application/GUI
    ../LCRMeter/Application/GUI/: App.cpp button.cpp checkbox.cpp container.cpp desktop.cpp dialog.cpp entry.cpp EventCatcher.cpp graph.cpp gui.cpp itemChooser.cpp keyboard.cpp label.cpp menu.cpp MenuAction.cpp MenuBack.cpp MenuBool.cpp MenuChooser.cpp MenuValue.cpp progressbar.cpp Radiobutton.cpp sevensegment.cpp slider.cpp textfield.cpp Unit.cpp widget.cpp window.cpp
  group Project/Application/GUI/Dialog
    ../LCRMeter/Application/GUI/Dialog/: ItemChooserDialog.cpp progress.cpp ValueInput.cpp
  group Project/Drivers/Board
    ../LCRMeter/Drivers/Board/: exti.c freertos_hooks.c log.c operators.cpp stm.c util.c
  group Project/Drivers/Board/AD5940
    ../LCRMeter/Drivers/Board/AD5940/: ad5940.c
  group Project/Drivers/Board/Display
    ../LCRMeter/Drivers/Board/Display/: display.c font.c
    src/: touch_ADS7843.cpp
  group Project/Drivers/STM32F3xx_HAL_Driver
    ../LCRMeter/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Project/Middlewares/FatFs
    ../LCRMeter/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../LCRMeter/Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Project/Middlewares/FreeRTOS
    ../LCRMeter/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../LCRMeter/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../LCRMeter/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    src/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Project/Middlewares/STM32_USB_Device_Library
    ../LCRMeter/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../LCRMeter/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Project/Src
    ../LCRMeter/Src/: fatfs.c freertos.c main.c stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_tim.c stm32f3xx_it.c system_stm32f3xx.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c user_diskio.c
  group Project/startup
    src/startup/: startup_stm32f303xe.s
